# Keil uVision project test.uvprojx, settings and files
target project_blink (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\CMSIS Liberary\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f10x_cl.s
  group cmsis core
    ./CMSIS Liberary/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS Liberary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group main
    ./: main.c delay.c bsp.c tm_stm32f4_hd44780.c
  group cmsis driver
    ./CMSIS Liberary/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c
software components: CMSIS:CORE 4.1.0
