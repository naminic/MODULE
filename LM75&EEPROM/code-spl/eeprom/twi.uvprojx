# Keil uVision project twi.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: twi +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\CMSIS Liberary\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f10x_cl.s
  group main
    ./: main.c i2c_ee.c serial.c
  group cmsis core
    ./CMSIS Liberary/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS Liberary/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cmsis driver
    ./CMSIS Liberary/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_rcc.c
software components: CMSIS:CORE 4.1.0
