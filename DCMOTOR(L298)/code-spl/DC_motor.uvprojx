# Keil uVision project DC_motor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DC_motor
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: .\CMSIS_Liberary\cmsis\cm3\CoreSupport;.\CMSIS_Liberary\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f10x_cl.s
  group cmsis core
    ./CMSIS_Liberary/cmsis/cm3/CoreSupport/: core_cm3.c
    ./CMSIS_Liberary/cmsis/cm3/DeviceSupport/st/STM32F10x/: system_stm32f10x.c
  group cmsis driver
    ./CMSIS_Liberary/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c
  group main
    ./: main.c delay.c dcmotor.c
